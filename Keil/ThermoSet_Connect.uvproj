# Keil uVision project ThermoSet_Connect.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ThermoSet_Connect +hex
  c flags: Optim=1
  c include: ..\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ../src/: adc.c cust_lcd.c delay.c eeprom.c esp01.c esp01_call.c i2c.c interrupt.c keypad.c lcd.c lcd_display.c main.c rtc.c uart.c
